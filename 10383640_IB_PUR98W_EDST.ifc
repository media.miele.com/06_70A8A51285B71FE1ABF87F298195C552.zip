Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: e54c7f58-19ef-4558-8e45-ed0324d41c76, NumberOfSaves: 1]
File name: 0001
Time: 2026-09-07T15:08:56+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 10383640_IB_PUR98W_EDST:28419854_IB_10383640_PUR98W_EDST, (2)
In: Default
Type - Material: z_Miele_Design_Glass, Aluminum, z_Miele_Design_CLST, z_Miele_Design_Steel_Chrom, z_Miele_Connection_ExhaustAir, z_Miele_Connection_Electric
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 898 mm; Depth: 500 mm
Classification: E1090320 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 28419854_IB_10383640_PUR98W_EDST; sets with these values: 2
